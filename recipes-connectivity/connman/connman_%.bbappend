FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-dnsproxy-byte-aligned-memory-access.patch"

