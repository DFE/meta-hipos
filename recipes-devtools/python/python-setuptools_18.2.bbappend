
RDEPENDS_${PN} += "\
  python-pkgutil \
  python-misc \
"
