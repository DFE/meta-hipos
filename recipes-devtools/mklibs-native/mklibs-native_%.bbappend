# this package is not c++17 compliant yet but your local g++ default might be
CXXFLAGS += " -std=gnu++11 "
