FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://options-ssr-read-and-cmd56.patch "

