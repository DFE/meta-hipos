# pinentry is not needed
RRECOMMENDS:${PN}:remove = "pinentry"
