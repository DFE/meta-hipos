# SPDX-License-Identifier: MIT
# Copyright (C) 2026 iris-GmbH infrared & intelligent sensors

require recipes-support/hipos-sd-img/hipos-sd-img.inc
