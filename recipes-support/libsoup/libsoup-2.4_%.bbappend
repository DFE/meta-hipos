FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-soup_websocket_connection_read-max-size.patch \
"

