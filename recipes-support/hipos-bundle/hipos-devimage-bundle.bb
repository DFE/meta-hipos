# SPDX-License-Identifier: MIT
# Copyright (C) 2025 iris-GmbH infrared & intelligent sensors

require recipes-support/hipos-bundle/hipos-bundle.inc
