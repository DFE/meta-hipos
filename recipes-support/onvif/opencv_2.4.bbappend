FILES_${PN}-dbg += "${datadir}/OpenCV/java/.debug"
