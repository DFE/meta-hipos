# SPDX-License-Identifier: MIT
# Copyright (C) 2026 iris-GmbH infrared & intelligent sensors

require recipes-support/hipos-sd-preparation/hipos-sd-preparation.inc
