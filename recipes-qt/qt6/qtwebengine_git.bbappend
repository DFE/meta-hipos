
# gatesgarth: Avoid error:
# | Package xkbcommon was not found in the pkg-config search path.
DEPENDS += "libxkbcommon"
