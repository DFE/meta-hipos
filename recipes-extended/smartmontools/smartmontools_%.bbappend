# Remove s-nail recommendation of original recipe

RRECOMMENDS:${PN}:remove = "s-nail"
