
REQUIRED_DISTRO_FEATURES_remove_mx8 = "wayland"
