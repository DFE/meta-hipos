# pointercal is only used for touchscreen emulation in qemu
RRECOMMENDS:${PN}:remove = "pointercal"
