# 'mesa' does not build with out this dependency in yocto/morty
DEPENDS += " libdrm "
