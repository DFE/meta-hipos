require hipos-image.inc

export IMAGE_BASENAME = "hipos-prodimage"
