COMPATIBLE_MACHINE = "(imx6qsabrelite|nitrogen6x|dres0280_rev_a|himx0280)"
SRCREV = "1974f9c88ecd43e8019f7d24c08b270e09693668"
