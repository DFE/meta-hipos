FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append = " file://0001-test-Makefile-Add-include-path-to-CC-command.patch "
