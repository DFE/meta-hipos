FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0001-HYP-13714-increase-vpu-instances-from-32-to-64.patch "
