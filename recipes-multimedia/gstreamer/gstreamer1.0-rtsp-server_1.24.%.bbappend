# Disable meta-freescale rtsp-server for himx0294 to keep in sync with gstreamer1.0
DEFAULT_PREFERENCE:himx0294 = "-1"
