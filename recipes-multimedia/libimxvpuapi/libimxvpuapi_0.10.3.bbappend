FILEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
        file://0001-imxvpuapi-imxvpuapi_vpulib.c-Output-AUD-NALs-manuall.patch \
"

