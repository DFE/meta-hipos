# Remove theora and hence ogg support from
# avcodec as part of ffmpeg.
PACKAGECONFIG:remove = "theora"
