FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://background.patch \
"

