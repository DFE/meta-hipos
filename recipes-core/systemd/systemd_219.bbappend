# Disable systemd version 219
# With this version mounts of file-systems are unmounted, if they are mounted via udev scripts.
DEFAULT_PREFERENCE = "-1"

