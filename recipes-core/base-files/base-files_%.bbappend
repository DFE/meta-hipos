FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

dirs755:append = " /mnt/hydra /mnt/keystore /mnt/datastore /mnt/provisioning"
